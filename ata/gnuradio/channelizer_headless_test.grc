options:
  parameters:
    author: luigi
    generate_options: no_gui
    id: channelizer_headless_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ch_n
  id: variable
  parameters:
    value: '8'
  states: {}
- name: channel_fs
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: channel_fs_0
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: freq
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_fs/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 500e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '72'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: ch_n
    osr: '1.0'
    taps: variable_low_pass_filter_taps_0
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0_0_0_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0_0_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
