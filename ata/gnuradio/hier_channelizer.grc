options:
  parameters:
    author: luigi
    generate_options: qt_gui
    id: turbo_seti
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ch_n
  id: variable
  parameters:
    value: '3'
  states: {}
- name: channel_fs
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: freq
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: pfb_channelizer_hier_ccf_0
  id: pfb_channelizer_hier_ccf
  parameters:
    atten: '100'
    bw: '1.0'
    n_filterbanks: '4'
    outchans: None
    ripple: '0.1'
    taps: None
    tb: '0.2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_fs
    fc: '0'
    fftsize: '1024'
    name: '"Channel 1"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: Input
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_fs
    fc: '0'
    fftsize: '1024'
    name: '"Channel 3"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_fs
    fc: '0'
    fftsize: '1024'
    name: '"Channel 2"'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [pfb_channelizer_hier_ccf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_channelizer_hier_ccf_0, '1', qtgui_waterfall_sink_x_0_2, '0']
- [pfb_channelizer_hier_ccf_0, '2', qtgui_waterfall_sink_x_0_1, '0']
- [soapy_limesdr_source_0, '0', pfb_channelizer_hier_ccf_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
