options:
  parameters:
    author: luigi
    generate_options: no_gui
    id: usrp_simple
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"mgmt_addr=10.11.1.20"'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
