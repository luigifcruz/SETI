options:
  parameters:
    author: luigi
    generate_options: qt_gui
    id: channelizer_headless
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ch_n
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_fs
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: channel_fs_0
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: freq
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_fs/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 200e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: ch_n
    osr: '1.0'
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: Input
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"mgmt_addr=10.11.1.20"'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', pfb_channelizer_ccf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
