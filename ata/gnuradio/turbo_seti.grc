options:
  parameters:
    author: luigi
    generate_options: qt_gui
    id: turbo_seti
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ch_n
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_fs
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: channel_fs_0
  id: variable
  parameters:
    value: samp_rate/ch_n
  states: {}
- name: freq
  id: variable
  parameters:
    value: 545.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_fs/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 200e3
    win: window.WIN_BLACKMAN
  states: {}
- name: ata_fft_block_0
  id: ata_fft_block
  parameters:
    fft_size: int(channel_fs)
  states: {}
- name: ata_fft_block_0_0
  id: ata_fft_block
  parameters:
    fft_size: int(channel_fs)
  states: {}
- name: ata_fft_block_0_1
  id: ata_fft_block
  parameters:
    fft_size: int(channel_fs)
  states: {}
- name: ata_fft_block_0_2
  id: ata_fft_block
  parameters:
    fft_size: int(channel_fs)
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: ch_n
    osr: '1.0'
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Mag"'
    ncols: '8192'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Mag"'
    ncols: '8192'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Mag"'
    ncols: '8192'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Mag"'
    ncols: '8192'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: Input
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [ata_fft_block_0, '0', qtgui_time_raster_sink_x_0, '0']
- [ata_fft_block_0_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [ata_fft_block_0_1, '0', qtgui_time_raster_sink_x_0_0_0_0, '0']
- [ata_fft_block_0_2, '0', qtgui_time_raster_sink_x_0_0_0, '0']
- [pfb_channelizer_ccf_0, '0', ata_fft_block_0, '0']
- [pfb_channelizer_ccf_0, '1', ata_fft_block_0_0, '0']
- [pfb_channelizer_ccf_0, '2', ata_fft_block_0_2, '0']
- [pfb_channelizer_ccf_0, '3', ata_fft_block_0_1, '0']
- [soapy_limesdr_source_0, '0', pfb_channelizer_ccf_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
